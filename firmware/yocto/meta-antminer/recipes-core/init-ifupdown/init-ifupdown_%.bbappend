FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
# lo + eth0 via DHCP only; poky's default file also lists interfaces this board does not have
