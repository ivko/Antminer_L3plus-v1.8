FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
# host key on the persistent /config partition instead of the ramfs (see antminer-base)
